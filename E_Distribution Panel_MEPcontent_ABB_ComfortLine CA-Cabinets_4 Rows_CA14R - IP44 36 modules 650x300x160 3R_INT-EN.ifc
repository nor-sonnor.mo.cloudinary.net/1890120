Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-03-11T14:30:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 11 14:30:54 2020 * Host: DSBIRNE-RO-DE * Database: C:\Users\Dsbirne\AppData\Local\Temp\{49626528-8AAE-4B03-AEF0-7FAF52A97AE9}\ifc * Database version: 5507 * Database creation date: Wed Mar 11 14:30:52 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 11 14:30:53 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 11 14:30:53 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: CA14R - IP44 36 modules 650x300x160 3R, E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN:CA14R - IP44 36 modules 650x300x160 3R:1300709
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 160 mm; Height (mm): 650 mm; Width (mm): 300 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP44; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Delivery Form: Partly assembled cabinet; Door Opening Angle [degrees]: 120; Door Type: Metal door; Grid Units (GU): 4; Interior Fitting: Expanded with distributor fields; Locking Type — Lock: Standard closure; Material of Enclosures: Sheet steel; Number of Rows: 3; Panel Width (PW): 1; RAL-Number: 9016; Space Units [SU]: 36
Type - Identity Data - Article Description: CA14R Comp.DB 1PW 3R IP44; Article Type: CA14R - IP44 36 modules 650x300x160 3R; Base Family Version: 12.11; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: CA14R Comp.DB 1PW 3R IP44; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.11; Manufacturer: ABB; Manufacturer Art. No.: 2CPX052229R9999; Manufacturer URL: https://new.abb.com/products/2CPX052229R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: CA14R - IP44 36 modules 650x300x160 3R; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: CA14R - IP44 36 modules 650x300x160 3R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - White: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Back Wall Void Width: 277 mm; Bottom Clearance: 500 mm; Bottom Width: 249.82 mm; Door Width: 275 mm; Door Width 2: 275 mm; Double Door: no; Family Name: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN; Front Clearance: 300 mm; Half Width: 137.5 mm; Handle: yes; Handle Height: 242.5 mm; Hole Depth: 147.5 mm; Hole Height: 625 mm; Hole Width: 275 mm; Left Clearance: 250 mm; Offset: 160 mm; Right Clearance: 300 mm; Top Clearance: 300 mm; Upper Width 1: 111.3 mm; Upper Width 2: 111.3 mm; Upper Width 3: 111.3 mm; Upper Width 4: 111.3 mm; Wall Thickness: 12.5 mm; Width Safe: 276.8 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 2.7755 m2; Volume: 0.0312 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Design Option: Main Model; Function Code: E6211; Mark: 2
Other - Family: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN: CA14R - IP44 36 modules 650x300x160 3R; Family and Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN: CA14R - IP44 36 modules 650x300x160 3R; Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN: CA14R - IP44 36 modules 650x300x160 3R; Type Id: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_4 Rows_INT-EN: CA14R - IP44 36 modules 650x300x160 3R
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
