Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-03-11T14:32:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 11 14:32:05 2020 * Host: DSBIRNE-RO-DE * Database: C:\Users\Dsbirne\AppData\Local\Temp\{713E192B-4DE9-4F12-9C77-ADFCB44B0F6A}\ifc * Database version: 5507 * Database creation date: Wed Mar 11 14:32:03 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 11 14:32:04 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 11 14:32:04 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: CA45B - IP44 240 modules 800x1050x160 empty with door, E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN:CA45B - IP44 240 modules 800x1050x160 empty with door:1306803
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 160 mm; Height (mm): 800 mm; Width (mm): 1050 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP44; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Door Opening Angle [degrees]: 120; Door Type: Metal door; Grid Units (GU): 5; Interior Fitting: Pre-assembled for installation of modules and CombiLine Modules; Material of Enclosures: Sheet steel; Number of Rows: 5; Panel Width (PW): 4; RAL-Number: 9016; Space Units [SU]: 240
Type - Identity Data - Article Description: CA45B Comp.DB 3PW 5R empty w.door; Article Type: CA45B - IP44 240 modules 800x1050x160 empty with door; Base Family Version: 12.11; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: CA45B Comp.DB 3PW 5R empty w.door; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.11; Manufacturer: ABB; Manufacturer Art. No.: 2CPX052178R9999; Manufacturer URL: https://new.abb.com/products/2CPX052178R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: CA45B - IP44 240 modules 800x1050x160 empty with door; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: CA45B - IP44 240 modules 800x1050x160 empty with door; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - White: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Back Wall Void Width: 1027 mm; Bottom Clearance: 500 mm; Bottom Width: 249.82 mm; Door Visibility: yes; Door Visibility2: yes; Door Width: 525.9 mm; Door Width 2: 499.1 mm; Double Door: yes; Family Name: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN; Front Clearance: 550 mm; Half Width: 512.5 mm; Handle: yes; Handle Height: 317.5 mm; Hole Depth: 146 mm; Hole Height: 775 mm; Hole Width: 1025 mm; Left Clearance: 550 mm; Left Door: yes; Left Door Type: E_Distribution Panel_MEPcontent_ABB_Left Door_INT-EN_Shared: CTB25; Offset: 160 mm; Right Clearance: 550 mm; Right Door: yes; Right Door Type: E_Distribution Panel_MEPcontent_ABB_Right Door_INT-EN_Shared: CTB25S; Top Clearance: 300 mm; Upper Width 1: 361.3 mm; Upper Width 2: 611.3 mm; Upper Width 3: 861.3 mm; Upper Width 4: 111.3 mm; Wall Thickness: 12.5 mm; Width Safe: 1026.8 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 7.4635 m2; Volume: 0.1344 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Function Code: E6211; Mark: 2
Other - Family: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN: CA45B - IP44 240 modules 800x1050x160 empty with door; Family and Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN: CA45B - IP44 240 modules 800x1050x160 empty with door; Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN: CA45B - IP44 240 modules 800x1050x160 empty with door; Type Id: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_5 Rows_Empty Cabinet_INT-EN: CA45B - IP44 240 modules 800x1050x160 empty with door
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
