Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-03-09T14:07:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 09 14:07:20 2020 * Host: ctontea-ro-de * Database: C:\Users\CTontea\AppData\Local\Temp\{0E94E4A9-8346-4985-B38C-4714607C6E9F}\ifc * Database version: 5507 * Database creation date: Mon Mar 09 14:07:19 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 09 14:07:20 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 09 14:07:20 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcElectricDistributionBoard: CA23RT - IP44 48 modules 500x550x160 transparent door 2R, E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN:CA23RT - IP44 48 modules 500x550x160 transparent door 2R:6613
In: Level 1
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 160 mm; Height (mm): 500 mm; Width (mm): 550 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP44; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Delivery Form: Partly assembled cabinet; Door Opening Angle [degrees]: 120; Door Type: Transparent door; Grid Units (GU): 3; Interior Fitting: Expanded with distributor fields; Locking Type — Lock: Standard closure; Material of Enclosures: Sheet steel; Number of Rows: 2; Panel Width (PW): 2; RAL-Number: 9016; Space Units [SU]: 48
Type - Identity Data - Article Description: CA23RT Comp.DB 2PW 2R trans.door; Article Type: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; Base Family Version: 12.11; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.11; Manufacturer: ABB; Manufacturer Art. No.: 2CPX052251R9999; Manufacturer URL: https://new.abb.com/products/2CPX052251R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: IP44 48 modules 500x550x160 transparent door 2R; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - White: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Back Wall Void Width: 527 mm; Bottom Clearance: 500 mm; Bottom Width: 249.82 mm; Door Width: 525 mm; Door Width 2: 525 mm; Double Door: no; Family Name: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN; Front Clearance: 550 mm; Half Width: 262.5 mm; Handle: yes; Handle Height: 167.5 mm; Hole Depth: 147.5 mm; Hole Height: 475 mm; Hole Width: 525 mm; Left Clearance: 250 mm; Offset: 160 mm; Right Clearance: 550 mm; Top Clearance: 300 mm; Upper Width 1: 361.3 mm; Upper Width 2: 111.3 mm; Upper Width 3: 111.3 mm; Upper Width 4: 111.3 mm; Wall Thickness: 12.5 mm; Width Safe: 526.8 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 4.2385 m2; Volume: 0.044 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Function Code: E6211; Mark: 1
Other - Family: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; Family and Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; Type: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN: CA23RT - IP44 48 modules 500x550x160 transparent door 2R; Type Id: E_Distribution Panel_MEPcontent_ABB_ComfortLine CA-Cabinets_2-3 Rows_INT-EN: CA23RT - IP44 48 modules 500x550x160 transparent door 2R
Phasing - Phase Created: New Construction
Visibility - Show Service Area: no
